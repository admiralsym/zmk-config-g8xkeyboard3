## config/boards/shields/g8xkeyboard/Kconfig.defconfig
```kconfig
if SHIELD_G8XKEYBOARD

config ZMK_KEYBOARD_NAME
    default "g8xkeyboard"

endif
```
